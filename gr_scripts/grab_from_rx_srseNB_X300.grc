options:
  parameters:
    generate_options: qt_gui
    id: grab_from_rx_srseNB_X300
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cent_freq
  id: variable
  parameters:
    value: 2.56e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/wcsng-23/Frederik/beam_armor/gr_scripts/rx0.iq
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/wcsng-23/Frederik/beam_armor/gr_scripts/rx1.iq
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: cent_freq
    center_freq1: cent_freq
    gain0: '10'
    gain1: '10'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '1', blocks_file_sink_1, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-402-g54d199a2
